# IAR project SensorTag.ewp, settings and files
configuration CC2541DK-Sensor (8051)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2541F256.i51
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; HAL_LCD=FALSE; HAL_LED=TRUE; HAL_I2C=TRUE; HAL_ADC=FALSE
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\common; ..\include; ..\hal\include; ..\hal\target\CC2541ST; ..\common\cc2540
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\common\cc2540\ti_51ew_cc2540b.xcl
  group APP
    ../Source/: sensors.c sensors.h SensorTag_Main.c sleepTimer.c sleepTimer.h uart.c uart.h
  group HAL
    ../hal/target/CC2541ST/: hal_assert.c hal_board_cfg.h hal_i2c.c hal_i2c.h hal_mcu.h hal_sensor.c hal_sensor.h hal_types.h
    ../hal/include/: hal_board.h hal_defs.h
